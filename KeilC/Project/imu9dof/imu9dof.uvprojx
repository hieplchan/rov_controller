# Keil uVision project imu9dof.uvprojx, settings and files
target imu9dof (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: imu9dof
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F30X,
  c include: .\Inc;..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include;..\..\Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\Utilities\STM32F3_Discovery
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
    ./Src/: stm32f30x_it.c system_stm32f30x.c
  group STM32F3-Discovery
    ../../Utilities/STM32F3_Discovery/: stm32f3_discovery.c
  group STM32F30x_StdPeriph_Driver
    ../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_exti.c stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_rcc.c stm32f30x_syscfg.c
  group User
    ./Src/: main.c
software components: CMSIS:CORE 5.2.0
